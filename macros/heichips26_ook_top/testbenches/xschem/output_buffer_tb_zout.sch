v {xschem version=3.4.8RC file_version=1.3}
G {}
K {}
V {}
S {}
F {}
E {}
P 4 7 2670 -1380 2800 -1380 2800 -1160 2650 -1160 2650 -1380 2680 -1380 2670 -1380 {}
P 4 6 2810 -1380 3120 -1380 3120 -1130 2820 -1130 2810 -1130 2810 -1380 {}
P 4 7 1310 -790 1310 -830 1470 -830 1470 -630 1320 -630 1310 -630 1310 -790 {}
P 4 5 1510 -810 1980 -810 1980 -590 1510 -590 1510 -810 {}
T {output match} 2650 -1410 0 0 0.4 0.4 {}
T {output Filter} 2900 -1130 0 0 0.4 0.4 {}
T {Matching network} 1290 -860 0 0 0.4 0.4 {}
T {analog_0 pin} 1300 -780 1 0 0.4 0.4 {}
T {Filter Network} 1670 -840 0 0 0.4 0.4 {}
T {SMA connector Side (LOAD)} 1850 -840 0 0 0.4 0.4 {}
N 90 -220 90 -180 {lab=VDD}
N 90 -120 90 -80 {lab=GND}
N 2210 -700 2210 -670 {lab=GND}
N 2100 -700 2100 -670 {lab=GND}
N 830 -910 830 -880 {lab=GND}
N 850 -980 850 -860 {lab=GND}
N 820 -790 1000 -790 {lab=#net1}
N 1000 -790 1000 -780 {lab=#net1}
N 2210 -780 2220 -780 {lab=vout}
N 2100 -780 2100 -760 {lab=vout}
N 2210 -780 2210 -760 {lab=vout}
N 1000 -780 1350 -780 {lab=#net1}
N 680 -690 820 -690 {lab=#net2}
N 520 -1160 520 -1100 {lab=VDD}
N 540 -1120 540 -1100 {lab=VDDA}
N 290 -1040 380 -1040 {lab=VDD}
N 350 -440 380 -440 {lab=#net3}
N 350 -420 380 -420 {lab=#net4}
N 350 -400 380 -400 {lab=#net5}
N 350 -380 380 -380 {lab=#net6}
N 680 -710 710 -710 {lab=#net7}
N 350 -1020 380 -1020 {lab=#net8}
N 350 -1000 380 -1000 {lab=#net9}
N 350 -980 380 -980 {lab=#net10}
N 350 -960 380 -960 {lab=#net11}
N 350 -940 380 -940 {lab=#net12}
N 350 -920 380 -920 {lab=#net13}
N 350 -900 380 -900 {lab=#net14}
N 350 -880 380 -880 {lab=#net15}
N 350 -840 380 -840 {lab=#net16}
N 350 -820 380 -820 {lab=#net17}
N 350 -800 380 -800 {lab=#net18}
N 350 -780 380 -780 {lab=#net19}
N 350 -760 380 -760 {lab=#net20}
N 350 -740 380 -740 {lab=#net21}
N 350 -720 380 -720 {lab=#net22}
N 350 -700 380 -700 {lab=#net23}
N 350 -680 380 -680 {lab=#net24}
N 350 -660 380 -660 {lab=#net25}
N 350 -640 380 -640 {lab=#net26}
N 350 -620 380 -620 {lab=#net27}
N 350 -600 380 -600 {lab=#net28}
N 350 -580 380 -580 {lab=#net29}
N 350 -560 380 -560 {lab=#net30}
N 350 -540 380 -540 {lab=#net31}
N 350 -520 380 -520 {lab=#net32}
N 350 -500 380 -500 {lab=#net33}
N 350 -480 380 -480 {lab=#net34}
N 350 -460 380 -460 {lab=#net35}
N 290 -860 380 -860 {lab=VDD}
N 150 -1050 180 -1050 {lab=#net36}
N 150 -1030 180 -1030 {lab=#net37}
N 150 -1010 180 -1010 {lab=#net38}
N 150 -990 180 -990 {lab=#net39}
N 150 -970 180 -970 {lab=#net40}
N 150 -950 180 -950 {lab=#net41}
N 150 -930 180 -930 {lab=#net42}
N 150 -910 180 -910 {lab=#net43}
N 530 -320 530 -280 {lab=GND}
N 280 -1090 280 -1060 {lab=GND}
N 280 -1060 380 -1060 {lab=GND}
N 410 -1280 410 -1250 {lab=VDD}
N 410 -1190 410 -1150 {lab=GND}
N 680 -730 710 -730 {lab=#net44}
N 100 -420 100 -400 {lab=VDDA}
N 100 -340 100 -310 {lab=GND}
N 840 -1010 840 -870 {lab=VDDA}
N 860 -1010 860 -850 {lab=VDDA}
N 840 -1010 860 -1010 {lab=VDDA}
N 840 -1030 840 -1010 {lab=VDDA}
N 2100 -780 2210 -780 {lab=vout}
N 1350 -780 1350 -760 {lab=#net1}
N 1350 -700 1350 -670 {lab=GND}
N 1350 -780 1390 -780 {lab=#net1}
N 1570 -780 1600 -780 {lab=#net45}
N 1780 -780 1780 -720 {lab=#net46}
N 1710 -780 1780 -780 {lab=#net46}
N 1710 -780 1710 -720 {lab=#net46}
N 1660 -780 1710 -780 {lab=#net46}
N 1710 -660 1710 -620 {lab=GND}
N 1780 -660 1780 -620 {lab=GND}
N 1780 -780 1820 -780 {lab=#net46}
N 1880 -780 1910 -780 {lab=#net47}
N 1450 -780 1510 -780 {lab=#net48}
N 1970 -780 2100 -780 {lab=vout}
C {devices/code_shown.sym} -1220 -1730 0 0 {name=NGSPICE
only_toplevel=true
value="
.param VDD=1.5
.csparam VDD=VDD
.param temp=27
.options savecurrents klu reltol=1e-3 abstol=1e-12 gmin=1e-9 trtol=25 itl1=200 itl4=50 rshunt=1e9
.control

shell rm -f @schname\\\\.raw
shell rm -f ../plot_simulations/data/@schname\\\\.txt

save all
set wr_vecnames
set wr_singlescale

op
write @schname\\\\.raw
set appendwrite
ac lin 200 200e6 600e6
write @schname\\\\.raw
let Rs = 50
let zout = -v(vout)
let zout_mag = mag(zout)
let zout_ph = 180/PI*cphase(zout)
let zout_re = real(zout)
let zout_im = imag(zout)
let Gam = (zout - Rs)/(zout + Rs)
let Gmag = mag(Gam)
let S11_dB = db(Gmag)
let ML_dB = -10*log10(1 - Gmag*Gmag)
plot real(zout) imag(zout) xlimit 200e6 600e6
wrdata ../plot_simulations/data/@schname\\\\.txt mag(zout) phase(zout) real(zout) imag(zout)

meas ac zmag_433 find zout_mag when frequency=433.92e6
meas ac zph_433 find zout_ph when frequency=433.92e6
meas ac zre_433 find zout_re when frequency=433.92e6
meas ac zim_433 find zout_im when frequency=433.92e6
meas ac S11_433 find S11_dB when frequency=433.92e6
meas ac ML_433 find ML_dB when frequency=433.92e6

unset appendwrite

echo
echo   Zout magnitude = $&zmag_433 ohm
echo   Zout real      = $&zre_433 ohm
echo   Zout imag      = $&zim_433 ohm
echo   Zout phase     = $&zph_433 deg
echo
echo   S11            = $&S11_433 dB
echo   mismatch loss  = $&ML_433 dB
echo

*quit
.endc
"}
C {devices/launcher.sym} 1700 -1410 0 0 {name=h2
descr="Simulate"
tclcommand="xschem save; xschem netlist; xschem simulate"
}
C {title-3.sym} 0 0 0 0 {name=l2 author="Belal ELshinnawey" rev=1.0 lock=true}
C {devices/launcher.sym} 1700 -1290 0 0 {name=h1
descr="Load waves"
tclcommand="xschem raw_read $netlist_dir/[file rootname [file tail [xschem get current_name]]].raw ac"
}
C {devices/launcher.sym} 1700 -1350 0 0 {name=h3
descr="Annotate OP"
tclcommand="set show_hidden_texts 1; xschem annotate_op"
}
C {devices/vsource.sym} 90 -150 0 0 {name=VDD value=\{VDD\}}
C {devices/gnd.sym} 90 -80 0 0 {name=l3 lab=GND}
C {vdd.sym} 90 -220 0 0 {name=l7 lab=VDD}
C {devices/lab_pin.sym} 2220 -780 0 1 {name=l12 sig_type=std_logic lab=vout}
C {devices/code_shown.sym} 1530 -1710 0 0 {name=MODEL only_toplevel=true
format="tcleval( @value )"
value="
.lib cornerMOSlv.lib mos_tt
.lib cornerMOShv.lib mos_tt
.lib cornerRES.lib res_typ
.lib cornerDIO.lib dio_tt
.lib cornerCAP.lib cap_typ
.include /home/belal/HeiChips/heichips26-on-off/macros/heichips26_ook_top/netlist/pex/heichips26_ook_top_magic_pex_3.spice
.include /home/belal/HeiChips/heichips26-on-off/macros/heichips26_ook_top/macros/ook_analog_system/netlist/pex/output_buffer_magic_pex_3.spice
.include /home/belal/HeiChips/heichips26-on-off/IHP-Open-PDK/ihp-sg13cmos5l/libs.ref/sg13cmos5l_io/spice/sg13cmos5l_io.spi
"}
C {devices/isource.sym} 2100 -730 0 0 {name=IAC_PROBE value="ac 1"}
C {devices/gnd.sym} 2100 -670 0 0 {name=l21 lab=GND}
C {res.sym} 2210 -730 0 0 {name=RBIAS value=10meg footprint=1206 device=resistor m=1}
C {devices/gnd.sym} 2210 -670 0 0 {name=l22 lab=GND}
C {sg13cmos5l_IOPadAnalog.sym} 1170 -890 3 1 {name=x1}
C {devices/gnd.sym} 830 -910 2 0 {name=l13 lab=GND}
C {devices/gnd.sym} 850 -980 2 0 {name=l18 lab=GND}
C {vdd.sym} 520 -1160 0 0 {name=lvddb2 lab=VDD}
C {vdd.sym} 540 -1120 0 0 {name=lvddb5 lab=VDDA
value=\{VDD/2\}}
C {noconn.sym} 350 -460 0 0 {name=l24}
C {noconn.sym} 350 -480 0 0 {name=l25}
C {noconn.sym} 350 -500 0 0 {name=l26}
C {noconn.sym} 350 -520 0 0 {name=l27}
C {noconn.sym} 350 -540 0 0 {name=l28}
C {noconn.sym} 350 -560 0 0 {name=l29}
C {noconn.sym} 350 -580 0 0 {name=l30}
C {noconn.sym} 350 -600 0 0 {name=l31}
C {noconn.sym} 350 -620 0 0 {name=l32}
C {noconn.sym} 350 -640 0 0 {name=l33}
C {noconn.sym} 350 -660 0 0 {name=l34}
C {noconn.sym} 350 -680 0 0 {name=l35}
C {noconn.sym} 350 -700 0 0 {name=l36}
C {noconn.sym} 350 -720 0 0 {name=l37}
C {noconn.sym} 350 -740 0 0 {name=l38}
C {noconn.sym} 350 -760 0 0 {name=l39}
C {noconn.sym} 350 -780 0 0 {name=l40}
C {noconn.sym} 350 -800 0 0 {name=l41}
C {noconn.sym} 350 -820 0 0 {name=l42}
C {noconn.sym} 350 -840 0 0 {name=l43}
C {noconn.sym} 350 -880 0 0 {name=l44}
C {noconn.sym} 350 -900 0 0 {name=l45}
C {noconn.sym} 350 -920 0 0 {name=l46}
C {noconn.sym} 350 -940 0 0 {name=l47}
C {noconn.sym} 350 -960 0 0 {name=l48}
C {noconn.sym} 350 -980 0 0 {name=l49}
C {noconn.sym} 350 -1000 0 0 {name=l50}
C {noconn.sym} 350 -1020 0 0 {name=l51}
C {noconn.sym} 150 -910 0 0 {name=l52}
C {noconn.sym} 150 -930 0 0 {name=l53}
C {noconn.sym} 150 -950 0 0 {name=l54}
C {noconn.sym} 150 -970 0 0 {name=l55}
C {noconn.sym} 150 -990 0 0 {name=l56}
C {noconn.sym} 150 -1010 0 0 {name=l57}
C {noconn.sym} 150 -1030 0 0 {name=l58}
C {noconn.sym} 150 -1050 0 0 {name=l59}
C {devices/gnd.sym} 530 -280 0 0 {name=lgnd1 lab=GND}
C {heichips26_ook_top_pex.sym} 540 -710 0 0 {name=x3}
C {capa.sym} 410 -1220 0 0 {name=C5
m=1
value=10.0p
footprint=1206
device="ceramic capacitor"}
C {vdd.sym} 410 -1280 0 0 {name=lvddb7 lab=VDD}
C {devices/gnd.sym} 410 -1150 0 0 {name=lgnd2 lab=GND
value=\{VDD/2\}}
C {vdd.sym} 290 -1040 2 0 {name=l60 lab=VDD}
C {devices/gnd.sym} 280 -1090 2 0 {name=lgnd3 lab=GND
value=\{VDD/2\}}
C {vdd.sym} 290 -860 3 0 {name=l62 lab=VDD}
C {noconn.sym} 710 -730 2 0 {name=l63}
C {noconn.sym} 710 -710 2 0 {name=l64}
C {noconn.sym} 350 -440 0 0 {name=l1}
C {noconn.sym} 350 -420 0 0 {name=l4}
C {noconn.sym} 350 -400 0 0 {name=l5}
C {noconn.sym} 350 -380 0 0 {name=l6}
C {devices/vsource.sym} 100 -370 0 0 {name=VDDSRC1 value=\{3.3\}}
C {vdd.sym} 100 -420 0 0 {name=lvddb4 lab=VDDA
value=\{3.3\}}
C {devices/gnd.sym} 100 -310 0 0 {name=lgnd4 lab=GND
value=\{VDD/2\}}
C {vdd.sym} 840 -1030 0 0 {name=lvddb1 lab=VDDA
value=\{VDD/2\}}
C {capa.sym} 1420 -780 1 1 {name=Cb2
m=1
value=2.3p
footprint=1206
device="ceramic capacitor"
}
C {ind.sym} 1350 -730 0 1 {name=L8
m=1
value=57n
footprint=1206
device=inductor}
C {devices/gnd.sym} 1350 -670 0 1 {name=l14 lab=GND}
C {capa.sym} 1630 -780 3 1 {name=C3
m=1
value=0.75p
footprint=1206
device="ceramic capacitor"}
C {ind.sym} 1540 -780 3 1 {name=L15
m=1
value=178n
footprint=1206
device=inductor}
C {capa.sym} 1710 -690 0 1 {name=C1
m=1
value=106p
footprint=1206
device="ceramic capacitor"}
C {ind.sym} 1780 -690 0 1 {name=L17
m=1
value=1.26n
footprint=1206
device=inductor}
C {devices/gnd.sym} 1710 -620 0 0 {name=lgndrload5 lab=GND}
C {devices/gnd.sym} 1780 -620 0 0 {name=lgndrload6 lab=GND}
C {capa.sym} 1940 -780 3 1 {name=C2
m=1
value=0.75p
footprint=1206
device="ceramic capacitor"}
C {ind.sym} 1850 -780 3 1 {name=L19
m=1
value=178n
footprint=1206
device=inductor}
